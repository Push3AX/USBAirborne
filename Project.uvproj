# Keil uVision project Project.uvproj, settings and files
target USBAirborne (MCS-51)
  device: CH554 WCH
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF)  IROM(0-0x3FFF) CLOCK(24000000)
  output: USBAirborne +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\
  link misc: REMOVEUNUSED
  group User
    ./: Debug.C Main.C
